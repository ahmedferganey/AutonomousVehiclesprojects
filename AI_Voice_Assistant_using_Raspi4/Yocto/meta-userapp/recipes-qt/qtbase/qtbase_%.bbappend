# meta-mylayer/recipes-qt/qtbase/qtbase_%.bbappend
PACKAGECONFIG:append = " examples"
